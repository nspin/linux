## arch/arm64/tos/Kconfig
```kconfig
menu "TrustZone Trusted OS"

config ARM64_TOS
	bool "TrustZone Trusted OS"
	default n
	help
	  Support running as a TrustZone Trusted OS

endmenu
```
